# Keil uVision project WY8S9003.uvproj, settings and files
target BLDC (MCS-51)
  device: WY8S9003XX Wayon
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: WY8S9003 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library\inc;..\bsp\inc;..\motor\inc
  link misc: REMOVEUNUSED
  group Library/Starup
    ../Library/Startup/: STARTUP_WY8S9003xx.A51
  group Library/src
    ../Library/src/: acmp.c adc.c gpio.c iap.c opa.c pwm.c timer.c uart.c wdt.c i2c.c spi.c
  group Motor
    ../motor/src/: main.c ipd.c motor.c pid.c application.c
  group Bsp
    ../bsp/src/: bsp.c
  group Common
    ../common/: common.c delay.c uart_printf.c wy8sxx_it.c
    ../motor/src/: util.c
